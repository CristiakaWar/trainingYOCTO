addtask do_build
do_build () {
	echo "I'm done"
}
